# Keil uVision project SPEED MEASURING DEVICE.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051 Cadence Design Systems Inc.
  cpu: IRAM(0-0x7F)  CLOCK(12000000) MODC2
  output: SPEED MEASURING DEVICE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SPEED MEASURING DEVICE.c
